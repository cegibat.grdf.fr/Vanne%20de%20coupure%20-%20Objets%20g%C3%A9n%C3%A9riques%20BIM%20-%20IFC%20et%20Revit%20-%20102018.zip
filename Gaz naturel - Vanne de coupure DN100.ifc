Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Numéro du projet
Time: 2018-10-18T17:01:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.4.0.0 - Alternate UI 16.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 18 17:01:54 2018 * Host: JB-MSI * Database: C:\Users\JB\AppData\Local\Temp\{21A2179C-1A09-441A-B546-197B79D4687E}\ifc * Database version: 5507 * Database creation date: Thu Oct 18 17:01:51 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 18 17:01:52 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 18 17:01:52 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 42, 12, 46, 804504; RefLongitude: -71, -2, 0, -602416; RefElevation: 0 mm
Autre - Adresse du projet: ## Rue Ville, Code postal; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: ## Rue Ville, Code postal; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 1
LongName: Niveau 1; Elevation: 0 mm
Graphismes(Type) - Couleur: 0; Epaisseur des lignes: 1; Motif des lignes: Centre; Symbole: M_Marqueur de niveau - Cercle: M_Marqueur de niveau - Cercle; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Pointe 8 mm
Autre - Catégorie: Niveaux; Famille: Niveau: Pointe 8 mm; Famille et type: Niveau: Pointe 8 mm; ID du type: Niveau: Pointe 8 mm; Type: Niveau: Pointe 8 mm
Contraintes - Elévation: 0 mm
Cotes - Hauteur de calcul: 0 mm
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 1; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet

# IfcFlowController: DN 100, Gaz naturel – Vanne de coupure:DN 100:207069
In: Niveau 1
Type - Material: Levier, VANNE
Type - Autre(Type) - Catégorie: Accessoire de canalisation; Nom de la famille: Gaz naturel – Vanne de coupure
Type - Données d'identification(Type) - Nom du type: DN 100
Type - Génie climatique(Type) - Méthode de perte de charge: Coefficient K à partir du tableau; Tableau de coefficient K: Vanne papillon - Ouverture complète
Pset_DistributionFlowElementCommon - Reference: DN 100
Autre - Catégorie: Accessoire de canalisation; Famille: Gaz naturel – Vanne de coupure: DN 100; Famille et type: Gaz naturel – Vanne de coupure: DN 100; ID du type: Gaz naturel – Vanne de coupure: DN 100; Type: Gaz naturel – Vanne de coupure: DN 100
Contraintes - Décalage: 0 mm; DN: 100 mm; Hôte: Niveau : Niveau 1; Lien vers les objets génériques BIM au gaz naturel: https://cegibat.grdf.fr/dossier-techniques/conception-batiments; Longueur poignée A: 300 mm; Matériau corps: VANNE; Matériau poignée: Levier; Niveau: Niveau: Niveau 1; Pression max: 0 Pa; Profondeur: 30 mm; Température max: 0 kg/K/s3; Température min: 0 kg/K/s3
Cotes - Diamétre de la canalisation: 125 mm; Diamètre du symbole: 125 mm; DN_BLOC: 100 mm; Hauteur B: 194 mm; Largeur 1: 50 mm; Largeur 2: 12.5 mm; Largeur du levier: 30 mm; Ligne du symbole: 9 mm; Ligne du symbole 1: 15 mm; Ligne du symbole 2: 24 mm; Longueur 1: 81.25 mm; Longueur 2: 10.5625 mm; Longueur 3: 12.5 mm; Rayon 1: 25.8 mm; Rayon 2: 30.1 mm; Rayon 3: 6.25 mm; Rayon de la canalisation: 62.5 mm; Rayon de la tige: 10.32 mm; Rayon nominal: 50 mm; Taille: 100 mmø-100 mmø; Taille maximale: 100 mm; Taille minimale: 100 mm; Volume: 0.000629558 m3
Données d'identification - Identifiant: 11
Génie climatique - Classification du système: Non défini
Graphismes - Utiliser l'échelle d'annotations: no
Isolation - Epaisseur d'isolation: 0 mm; Taille globale: 100 mmø-100 mmø
Phase de construction - Phase de création: Nouvelle construction
